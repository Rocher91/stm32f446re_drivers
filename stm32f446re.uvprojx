# Keil uVision project stm32f446re.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f446re
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ./Drivers/inc;./Drivers/src;./User/inc;./User/src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Drivers
    ./Drivers/src/: stm32f446xx_ADC_Driver.c stm32f446xx_Gpio_Driver.c stm32f446xx_SPI_Driver.c stm32f446xx_Timers_Driver.c stm32f446xx_NVIC.c stm32f446xx_I2C_Driver.c stm32f446xx_Clocks.c usart2.c stm32f446xx_Systick_Driver.c stm32f446xx_IWDG_Driver.c stm32f446xx_WWDG_Driver.c
  group User
    ./User/src/: main.c SPI_TX_Testing.c SPI_CMD_Handling.c SPI_TXOnly_Arduino.c TIM_BasicTimer.c TIM_BasicTimerIT.c Clocks.c TIM_IC.c TIM_04_OC_Toggle.c TIM_05_OC_Square_Signals.c TIM_06_OC_CCR_Reload.c TIM_07_OC_PWM.c TIM_08_OC_PWM_Servo.c TIM_09_OC_PWM_Measurement.c TIM_10_Encoder.c Systick_01_Measure.c Systick_02_delay.c Systick_03_elapsed_time.c IWDG_01.c WWDG_01.c
    ./: dma.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
